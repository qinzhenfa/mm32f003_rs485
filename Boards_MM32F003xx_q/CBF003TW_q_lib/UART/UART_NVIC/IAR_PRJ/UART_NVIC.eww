<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Backup of UART_NVIC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\UART_NVIC.ewp</path>
    </project>
    <batchBuild />
</workspace>
