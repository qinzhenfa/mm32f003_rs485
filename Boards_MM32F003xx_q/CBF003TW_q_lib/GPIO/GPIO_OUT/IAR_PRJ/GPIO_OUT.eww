<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Backup of GPIO_OUT.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\GPIO_OUT.ewp</path>
    </project>
    <batchBuild />
</workspace>
