# Keil uVision project GPIO_fromSWD.uvprojx, settings and files
target MM32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MM32F003NW MindMotion
  pack: MindMotion.MM32F003_DFP.1.0.2
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\..\..\Device\MM32F003_q\Include;..\..\..\..\..\Device\MM32F003_q\HAL_lib\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group USER
    ../USER/: main.c
  group STARTUP
    ../../../../../Device/MM32F003_q/Source/: system_MM32F003_q.c
    ../../../../../Device/MM32F003_q/Source/KEIL_StartAsm/: startup_MM32F003_q.s
  group HALlib
    ../../../../../Device/MM32F003_q/HAL_lib/src/: HAL_adc.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group Readme
    ../: README.TXT
